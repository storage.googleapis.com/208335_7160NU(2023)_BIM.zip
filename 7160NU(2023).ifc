Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2023-06-14T17:17:28
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20200210_1400(x64) - Exporter 20.2.12.1 - Alternate UI 20.2.12.1
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Jun 14 17:17:28 2023 * Host: DESKTOP-4UM54TC * Database: C:\Users\Vlad\AppData\Local\Temp\759ee022-3bab-4bb7-b5d6-2821236c801b\6850f4e2-7f4d-4afd-92c9-1d36bef10533\ifc * Database version: 5507 * Database creation date: Wed Jun 14 17:17:28 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Jun 14 17:17:28 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Jun 14 17:17:28 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Constraints(Type) - Elevation Base: Project Base Point
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head

# IfcDistributionPort (2)
Description: Flow; FlowDirection: SOURCE

# IfcFlowController: 7160NU Shower faucet, 7160NU(2023):7160NU Shower faucet:327779
In: Level 1
Type - PredefinedType: FAUCET; Material: Brass
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - NominalDepth: 107 mm; NominalHeight: 100.184 mm; NominalWidth: 342.5 mm
Type - General - Author: BIMStone; BIMObjectName: 7160NU(2023); ManufacturerName: Oras; ManufacturerURL: http://www.oras.com; NBSDescription: Shower mixers; NBSReference: 45-35-70/335; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_81; Uniclass2015Description: Shower thermostatic water supply sets; Uniclass2015Reference: Pr_40_20_87_81; Version: 1; VersionDate: 01/06/2023
Type - Green Building Properties - EAN Number: 6414150099410; EN Standard: EN1111; ETIM Class Number: EC011329 Shower mixing tap; Noise Class 02ls: I (ISO 3822); Sales Package dimensions (LxWxH): 359 x 128 x 75; UNSPSC Class Number: 30181700 Faucets or taps; URL Declaration of Asbestos: http://static.oras.com/doc/asbestos; URL Declaration of Conformity: http://static.oras.com/DoC/7160NU; URL Declaration Of Performance (DOP): http://static.oras.com/doc/DoP; URL Declaration of SCIP: http://static.oras.com/doc/SCIP; URL EcoLabel Declaration: http://static.oras.com/doc/EcoLabel; URL EU Packaging Declaration: http://static.oras.com/doc/packaging; URL REACH: http://static.oras.com/doc/reach; URL UWL: http://static.oras.com/UWL/7160NU
Type - Identity Data - 2D/3D/BIM Files URL: http://static.oras.com/bim/7160NU; 3D View: https://static.oras.com/AR/7160NU; Catalog Drawing URL: http://static.oras.com/catdrw/7160NU; Dimension Drawing URL: http://static.oras.com/dimdrw/7160NU; FDV Document URL: http://www.oras.com/datasheet/7160NU/en/fdv; Flow Drawing URL: http://static.oras.com/flowchart/7160NU; Group: Shower faucet; Installation and Maintenance Guide URL: http://static.oras.com/manual/7160NU; Interactive AR View URL: https://static.oras.com/AR/7160NU; Manufacturer: Oras; Market: Estonia;International;Lithuania;Latvia;Poland;Ukraine; Mobile Product Information URL: http://mpi.oras.com/7160NU; Model: 7160NU Shower faucet; Name_en: 7160NU Shower faucet; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Product Code: 7160NU; Product Family: Oras Optima; Product Image URL: http://static.oras.com/image/7160NU; Product URL: http://static.oras.com/7160NU; Technical DataSheet URL: http://www.oras.com/datasheet/7160NU/en; Type Name: 7160NU Shower faucet; Warranty Information URL: http://warranty.oras.com
Type - Materials and Finishes - FaucetMainMaterial: Brass
Type - Mechanical - Advanced Features: Inner body made of DZR brass; Aerator: Standard aerator; Backflow Prevention EN1717: EB; Connection: Eccentric coupling(s);Cover plate(s);Silencer(s); Connection Size: G3/4; Eco Flow At 300kPa: 0.00423776 m3/s; Flow Rate At 300kPa: 0.00776923 m3/s; Installation Type: Wall mounted; Installation Width: CC150± 15 mm; Lever Handle: Temperature control handle;Flow control handle;Hot/Cold symbols;Easy-Grip surface;Eco feature for water flow; Max. Hot Water Supply: 80 kg/K/s3; Mechanical Parts: Ceramic head part for flow control;Thermostatic cartridge for automatic temperature control;Non-return valve(s);Litter filter(s); Pressure Loss With Flow 02ls: 250000 Pa; Shower Parts: MagShelf; Surface treatment: Chrome; Temperature Adjustments: Safety stop against scalding at 38°C;The housing of the fittings conducts minimal heat; Working Pressure: 100 - 1000 kPa
Type - Other - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 7160NU(2023); Features: Thermostatic; Finish: Polished; Grade: n/a; Material: Brass/Plastic; ModelNumber: n/a; ModelReference: 7160NU; Name: 7160NU Shower faucet; ReplacementCost: n/a; Shape: Sculptured; Size: 220 x 240 x 180 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Constraints - DefaultElevation: 900 mm; Elevation from Level: 0 mm; Host: Level : Level 1; Level: Level: Level 1; Offset from Host: 0 mm
Dimensions - Area: 0.0714198 m2; ConnectorDirection: 0; ConnectorDirectionNote: 0-Up II 1-Back II 2-Down; InletConnectionSize: 15 mm; InletDistance: 150 mm; OutletAngle: 0 deg; Volume: 0.00268435 m3
Identity Data - Mark: 14
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Family: 7160NU(2023): 7160NU Shower faucet; Family and Type: 7160NU(2023): 7160NU Shower faucet; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 7160NU(2023): 7160NU Shower faucet; Type Id: 7160NU(2023): 7160NU Shower faucet; WarrantyStartDate: n/a
Phasing - Phase Created: Phase 1
